<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/nvsexternal.ewp</path>
  </project>
  <project>
    <path>$COM_TI_SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC1350_LAUNCHXL/release/iar/tirtos_builds_CC1350_LAUNCHXL_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
