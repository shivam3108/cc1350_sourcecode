# IAR project sensor_cc1350lp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sensor_cc1350lp.out
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: sensor_cc1350lp.ipcf
  group Configuration files
    Tools/: app.cfg
