<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sensor_cc1350lp.ewp</path>
    </project>
    <batchBuild />
</workspace>
