# IAR project cc1350lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC1350_LAUNCHXL; CC13XX; DeviceFamily_CC13X0; CC2650_HOSTTESTAPP; Display_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=8; NPI_USE_UART; USE_ICALL; USE_CORE_SDK; xBOARD_DISPLAY_EXCLUDE_LCD; xPOWER_SAVING; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $BLE_SRC$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $BLE_SRC$/controller/cc26xx/inc; $BLE_SRC$/inc; $BLE_SRC$/common/cc26xx; $BLE_SRC$/examples/host_test/cc26xx/app; $BLE_SRC$/icall/inc; $BLE_SRC$/inc; $BLE_SRC$/profiles/roles; $BLE_SRC$/profiles/roles/cc26xx; $BLE_SRC$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/npi/src; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC13XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: host_test_cc1350lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: host_test_cc1350lp_app.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1; CC2650=1
  ILINK.IlinkIcfFile: $BLE_SRC$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC13XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_multiMode_cc13x0.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_EXCLUDE_UART; CC1350_LAUNCHXL; CC13XX; DeviceFamily_CC13X0; CC2650_HOSTTESTAPP; Display_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=8; NPI_SPI_CONFIG=Board_SPI0; NPI_USE_SPI; POWER_SAVING; USE_CORE_SDK; USE_ICALL; xBOARD_DISPLAY_EXCLUDE_LCD; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $BLE_SRC$/controller/cc26xx/inc; $BLE_SRC$/inc; $BLE_SRC$/common/cc26xx; $BLE_SRC$/icall/inc; $BLE_SRC$/inc; $BLE_SRC$/profiles/roles; $BLE_SRC$/profiles/roles/cc26xx; $BLE_SRC$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/npi/src; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC13XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC13XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_multiMode_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
  group Application
    ../../../src/app/: host_test_app.c host_test_app.h
    $BLE_SRC$/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $BLE_SRC$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SRC_COMMON$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_COMMON$/heapmgr/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c
    $SRC_COMMON$/icall/src/inc/: icall.h icall_platform.h
    $BLE_SRC$/icall/inc/: icall_addrs.h
  group ICallBLE
    $BLE_SRC$/icall/app/: ble_user_config.c icall_api.c
    $BLE_SRC$/icall/inc/: ble_user_config.h icall_apimsg.h
  group NPI
    $SRC_COMMON$/npi/src/inc/: npi_ble.h npi_frame.h npi_rxbuf.h npi_task.h
    $SRC_COMMON$/npi/src/: npi_frame_hci.c npi_rxbuf.c npi_task.c
  group NPI/Transport
    $SRC_COMMON$/npi/src/inc/: npi_config.h npi_tl.h
    $SRC_COMMON$/npi/src/: npi_tl.c
  group NPI/Transport/SPI
    $SRC_COMMON$/npi/src/: npi_tl_spi.c
    $SRC_COMMON$/npi/src/inc/: npi_tl_spi.h
  group NPI/Transport/UART
    $SRC_COMMON$/npi/src/: npi_tl_uart.c
    $SRC_COMMON$/npi/src/inc/: npi_tl_uart.h
  group Startup
    $BLE_SRC$/target/: board.c
    ../config/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $BLE_SRC$/common/cc26xx/iar/: cc26xx_app.icf
