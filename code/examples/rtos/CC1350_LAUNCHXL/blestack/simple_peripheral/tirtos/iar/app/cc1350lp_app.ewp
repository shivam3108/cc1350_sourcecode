# IAR project cc1350lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC1350_LAUNCHXL; CC13XX; DeviceFamily_CC13X0; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; USE_CORE_SDK; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $BLE_SRC$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $BLE_SRC$/controller/cc26xx/inc; $BLE_SRC$/inc; $BLE_SRC$/common/cc26xx; $BLE_SRC$/examples/simple_peripheral/cc26xx/app; $BLE_SRC$/icall/inc; $BLE_SRC$/inc; $BLE_SRC$/profiles/dev_info; $BLE_SRC$/profiles/roles; $BLE_SRC$/profiles/roles/cc26xx; $BLE_SRC$/profiles/simple_profile; $BLE_SRC$/profiles/simple_profile/cc26xx; $BLE_SRC$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC13XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_cc1350lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_peripheral_cc1350lp_app.out
  ILINK.IlinkIcfFile: $BLE_SRC$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC13XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_multiMode_cc13x0.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_OAD_ExtFlash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC1350_LAUNCHXL; CC13XX; DeviceFamily_CC13X0; xDisplay_DISABLE_ALL; FEATURE_OAD; HAL_IMAGE_E; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; USE_CORE_SDK; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $BLE_SRC$/controller/cc26xx/inc; $BLE_SRC$/inc; $BLE_SRC$/common/cc26xx; $BLE_SRC$/icall/inc; $BLE_SRC$/inc; $BLE_SRC$/profiles/dev_info; $BLE_SRC$/profiles/oad/cc26xx; $BLE_SRC$/profiles/roles; $BLE_SRC$/profiles/roles/cc26xx; $BLE_SRC$/profiles/simple_profile; $BLE_SRC$/profiles/simple_profile/cc26xx; $BLE_SRC$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC13XXWARE$; $TI_RTOS_DRIVERS_BASE$; $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=1,OAD_IMG_E=1
  ILINK.IlinkConfigDefines: APP_IMAGE_START=0x1000
  ILINK.IlinkIcfFile: $BLE_SRC$/common/cc26xx/iar/cc26xx_app_oad.icf
  group Application
    $BLE_SRC$/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    ../../../src/app/: simple_peripheral.c simple_peripheral.h
    $BLE_SRC$/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $BLE_SRC$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SRC_COMMON$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_COMMON$/heapmgr/: heapmgr.h
    $SRC_COMMON$/icall/src/: icall.c icall_cc2650.c
    $SRC_COMMON$/icall/src/inc/: icall.h icall_platform.h
    $BLE_SRC$/icall/inc/: icall_addrs.h
  group ICallBLE
    $BLE_SRC$/icall/app/: ble_user_config.c icall_api.c
    $BLE_SRC$/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    $BLE_SRC$/inc/: gap.h gapgattserver.h gatt.h hci.h
    $BLE_SRC$/profiles/roles/: gapbondmgr.h
    $SRC_COMMON$/osal/src/inc/: osal_snv.h
  group Middleware/extflash
    $TI_RTOS_DRIVERS_BASE$/ti/mw/extflash/: ExtFlash.c ExtFlash.h
  group Profiles
    $BLE_SRC$/profiles/dev_info/cc26xx/: devinfoservice.c
    $BLE_SRC$/profiles/dev_info/: devinfoservice.h
    $BLE_SRC$/common/cc26xx/: ext_flash_layout.h
    $BLE_SRC$/inc/: gatt_profile_uuid.h gatt_uuid.h
    $BLE_SRC$/host/: gatt_uuid.c gattservapp_util.c
    $BLE_SRC$/profiles/oad/cc26xx/: oad.c oad.h oad_reset_service.c oad_target_external_flash.c oad_target_internal_flash.c
    $BLE_SRC$/profiles/roles/cc26xx/: peripheral.c peripheral.h
    $BLE_SRC$/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $BLE_SRC$/profiles/simple_profile/: simple_gatt_profile.h
    $BLE_SRC$/profiles/keys/cc26xx/: simplekeys.c
    $BLE_SRC$/profiles/keys/: simplekeys.h
  group Startup
    $BLE_SRC$/target/: board.c
    ../config/: ccfg_app_ble.c
    $BLE_SRC$/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    ../../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    $BLE_SRC$/common/cc26xx/iar/: cc26xx_app.icf cc26xx_app_oad.icf
